# EAGLE board DC2023A-1 (EAGLE 6.5.0), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
GND  (via drill 0.25) (continued)
  pour Top (no thermals): 84.96,32 81.41,32 81.41,35.31 86.23,35.31 86.87,34.67 86.87,33.02 86.23,33.02 86.23,34.42 85.98,34.67 85.22,34.67 84.96,34.42
  pour Bottom (no thermals): 84.96,32 81.41,32 81.41,35.18 84.58,35.18 84.96,34.8
  pour Bottom (no thermals): 104.27,41.27 104.27,36.58 102.11,36.58 101.73,36.2 101.73,35.05 99.82,35.05 99.82,36.58 100.2,36.96 100.2,40.26 101.22,41.27
  pour Top (no thermals): 96.52,32 92.96,32 92.96,35.31 97.79,35.31 98.42,34.67 98.42,33.02 97.79,33.02 97.79,34.42 97.54,34.67 96.77,34.67 96.52,34.42
  pour Bottom (no thermals): 96.52,32 92.96,32 92.96,35.18 96.14,35.18 96.52,34.8
  pour Top: 50.29,30.86 65.91,30.86 65.91,14.35 50.29,14.35
IBV_AUX  (via drill 0.25)
  Top 0.203: C20.1 110.4,24.42 110.57,24.59 112.47,24.59 113.03,25.15 113.03,26.04 112.14,26.92 112.14,27.34 U9.8 | 107.95,27.51 107.95,25.02 | U11.1 117.19,20.77 C25.1 | v113.41,21.21 113.41,21.03 114.17,20.77
  Top 0.254: U11.1 U11.2
  Top 0.406: C20.1 110.28,23.75 R28.2 108.71,22.23 108.08,22.23 108.08,22.99 C21.1 107.95,22.99 107.95,27.51 L9.2
  Top 1.016: 113.1,20.77 114.17,20.77 U11.1 | 108.71,22.23 108.71,21.59 109.78,20.77 113.1,20.77 | R30.2 113.2,20.73 113.16,20.83 113.1,20.77
  Bottom 0.406: D1.1 113.43,21.1 v113.41,21.21
  pour Top (no thermals): 107.06,19.81 107.06,26.42 106.68,26.8 105.66,26.8 105.66,28.32 107.82,28.32 108.33,27.81 108.33,24.51 111,24.51 111,21.46 119.38,21.46 119.38,19.94 119.25,19.81
INTVCC_LTC3604  (via drill 0.25)
  Top 0.203: v112.27,25.73 112.27,26.16 111.63,26.8 111.63,27.33 U9.7 | U9.1 108.99,29.94 108.97,29.97 v108.97,30.61 | U9.10 113.8,28.94 113.92,28.83 v113.92,25.4
  Bottom 0.203: C67.1 115.19,27.22 115.15,27.18 113.92,27.18 | 112.27,27.18 v112.27,25.73 | 112.27,27.18 109.09,27.18 108.97,27.3 v108.97,30.61 | 112.27,27.18 113.92,27.18 | 113.92,27.18 v113.92,25.4
ITH_LTC3604  (via drill 0.25)
  Top 0.203: U9.12 113.89,29.94 114.05,30.1 v114.05,30.86
  Bottom 0.203: v114.05,30.86 113.79,30.86 113.79,28.83 112.78,28.83 | 112.74,28.83 R102.2 112.78,28.83 | C68.1 110.49,28.57 112.78,28.57 112.78,28.83
N$1
  Top 0.406: P1.P 12.19,43.05 12.19,40.77 12.95,40.77 R17.1
N$2  (via drill 0.25)
  Top 0.203: v15.49,43.69 15.11,43.31 14.59,43.31 P1.N
  Bottom 0.203: v15.49,43.69 14.22,43.69 14.22,42.67 Q17.3
N$3
  Top 0.406: R26.2 LED1.P
N$4
  Top 0.406: P2.P 23.75,43.05 23.75,40.77 24.51,40.77 R18.1
N$5  (via drill 0.25)
  Top 0.203: v27.05,43.69 26.67,43.31 26.15,43.31 P2.N
  Bottom 0.203: v27.05,43.69 25.78,43.69 25.78,42.67 Q16.3
N$6
  Top 0.406: P3.P 35.31,43.05 35.31,40.77 36.07,40.77 R19.1
N$7  (via drill 0.25)
  Top 0.203: v38.61,43.69 38.23,43.31 37.71,43.31 P3.N
  Bottom 0.203: v38.61,43.69 37.34,43.69 37.34,42.67 Q15.3
N$8
  Top 0.406: P4.P 46.86,43.05 46.86,40.77 47.62,40.77 R20.1
N$9  (via drill 0.25)
  Top 0.203: v50.16,43.69 49.78,43.31 49.26,43.31 P4.N
  Bottom 0.203: v50.16,43.69 48.9,43.69 48.9,42.67 Q14.3
N$10
  Top 0.406: P5.P 58.42,43.05 58.42,40.77 59.18,40.77 R21.1
N$11  (via drill 0.25)
  Top 0.203: v61.72,43.69 61.34,43.31 60.82,43.31 P5.N
  Bottom 0.203: v61.72,43.69 60.45,43.69 60.45,42.67 Q13.3
N$12
  Top 0.406: P6.P 69.98,43.05 69.98,40.77 70.74,40.77 R22.1
N$13  (via drill 0.25)
  Top 0.203: v73.28,43.69 72.9,43.31 72.38,43.31 P6.N
  Bottom 0.203: v73.28,43.69 72.01,43.69 72.01,42.67 Q12.3
N$14
  Top 0.406: P7.P 81.53,43.05 81.53,40.77 82.3,40.77 R23.1
N$15  (via drill 0.25)
  Top 0.203: v84.84,43.69 84.45,43.31 83.94,43.31 P7.N
  Bottom 0.203: v84.84,43.69 83.57,43.69 83.57,42.67 Q11.3
N$16
  Top 0.406: P8.P 93.09,43.05 93.09,40.77 93.85,40.77 R24.1
N$17  (via drill 0.25)
  Top 0.203: v96.39,43.69 96.01,43.31 95.49,43.31 P8.N
  Bottom 0.203: v96.39,43.69 95.12,43.69 95.12,42.67 Q10.3
N$18  (via drill 0.25)
  Top 0.203: U21.16 113.67,11.01 113.67,11.05 114.55,11.05 v114.55,11.43 | R31.1 42.76,18.2 42.93,18.03 42.93,13.72 v42.8,13.72
  Route15 0.203: v114.55,11.43 114.55,11.3 104.78,11.3 103,12.95 43.18,12.95 42.8,13.34 v42.8,13.72
N$19
  Bottom 0.406: D1.3 113.03,20.45 112.27,21.21 C63.1 111.38,21.34 110.74,21.97 110.74,24.26 110.94,24.45 U23.4
N$20
  Bottom 0.203: R98.2 113.07,12.99 113.03,12.95 113.03,12.32 112.65,11.94 112.65,10.41 113.28,9.78 113.41,9.65 113.67,9.4 113.67,6.73 113.79,6.6 JP3.4
N$26
  Top 0.203: U10.A4 U10.A3 U10.B3
N$29
  Top 0.406: P9.P 22.99,3.3 22.99,5.59 22.23,5.59 R39.1
N$30  (via drill 0.25)
  Top 0.203: v19.68,2.67 20.07,3.05 20.59,3.05 P9.N
  Bottom 0.203: v19.68,2.67 20.95,2.67 20.95,3.68 Q8.3
N$31
  Top 0.406: P10.P 34.54,3.3 34.54,5.59 33.78,5.59 R40.1
N$32  (via drill 0.25)
  Top 0.203: v31.24,2.67 31.62,3.05 32.14,3.05 P10.N
  Bottom 0.203: v31.24,2.67 32.51,2.67 32.51,3.68 Q7.3
N$33
  Top 0.406: P11.P 46.1,3.3 46.1,5.59 45.34,5.59 R41.1
N$34  (via drill 0.25)
  Top 0.203: v42.8,2.67 43.18,3.05 43.7,3.05 P11.N
  Bottom 0.203: v42.8,2.67 44.07,2.67 44.07,3.68 Q6.3
N$35
  Top 0.406: P12.P 57.66,3.3 57.66,5.59 56.9,5.59 R42.1
N$36  (via drill 0.25)
  Top 0.203: v54.36,2.67 54.74,3.05 55.26,3.05 P12.N
  Bottom 0.203: v54.36,2.67 55.63,2.67 55.63,3.68 Q5.3
N$37
  Top 0.406: P13.P 69.22,3.3 69.22,5.59 68.45,5.59 R43.1
N$38  (via drill 0.25)
  Top 0.203: v65.91,2.67 66.29,3.05 66.81,3.05 P13.N
  Bottom 0.203: v65.91,2.67 67.18,2.67 67.18,3.68 Q4.3
N$39
  Top 0.406: P14.P 80.77,3.3 80.77,5.59 80.01,5.59 R44.1
N$40  (via drill 0.25)
  Top 0.203: v77.47,2.67 77.85,3.05 78.37,3.05 P14.N
  Bottom 0.203: v77.47,2.67 78.74,2.67 78.74,3.68 Q3.3
N$41
  Top 0.406: P15.P 92.33,3.3 92.33,5.59 91.57,5.59 R45.1
N$42  (via drill 0.25)
  Top 0.203: v89.03,2.67 89.41,3.05 89.93,3.05 P15.N
  Bottom 0.203: v89.03,2.67 90.3,2.67 90.3,3.68 Q2.3
N$43
  Top 0.406: P16.P 103.63,3.3 103.89,3.56 103.89,5.59 103.12,5.59 R46.1
N$44  (via drill 0.25)
  Top 0.203: v100.58,2.67 100.97,3.05 101.48,3.05 P16.N
  Bottom 0.203: v100.58,2.67 101.85,2.67 101.85,3.68 Q1.3
N$57
  Top 0.406: R27.1 LED2.P
N$58  (via drill 0.25)
  Top 0.203: v14.78,26.67 15.74,26.67 LED1.N
  Bottom 0.203: U24.4 15.61,25.85 15.62,25.91 15.62,26.42 15.37,26.67 v14.78,26.67
N$60  (via drill 0.25)
  Top 0.203: v18.29,26.67 17.28,26.67 LED2.N
  Bottom 0.203: U24.6 16.98,25.61 16.89,25.78 16.89,26.42 17.13,26.66 18.28,26.66 v18.29,26.67
N$61
  Bottom 0.203: 112.78,31.46 C69.1
  Bottom 0.406: R102.1 112.78,31.46
N$63
  Top 0.254: LED3.P 106.55,19.43 106.55,18.25 R35.1
N$64  (via drill 0.25)
  Top 0.203: R34.2 121.92,18.33 121.92,18.92 121.41,19.43 v121.03,19.43 120.9,19.43 U11.5
  Route15 0.203: v121.03,19.43 116.46,19.43 115.95,18.92 113.92,18.92 113.67,19.18 113.67,19.94 114.05,20.32 115.19,20.32 116.33,21.46 v116.33,22.35
  Bottom 0.203: v116.33,22.35 R101.1
N$66
  Top 0.203: U21.4 109.81,8.29 109.22,7.7 109.22,7.24 108.71,6.73 108.71,5.08 108.97,4.83 112.42,4.83 112.62,4.65 113.08,4.65 114.28,5.84 115.82,5.84 116.33,5.33 118.53,5.33 C37.1 118.53,6.39 118.49,6.48 | 119.98,7.75 R38.2
  Top 0.254: 118.49,6.48 119,6.48 119,6.99 119.63,7.62 119.63,7.75 119.98,7.75
N$68
  Top 0.203: U11.4 120.4,19.56 120.4,18.29 120.4,18.33 R33.2
N$69
  Top 0.203: U11.6 121.4,20.08 121.79,19.68 122.43,19.68 122.81,19.3 122.81,17.4 122.68,17.27 119.63,17.27 119.51,17.4 119.51,19.18 | 119.89,20.76 U11.3 119.9,19.44 119.63,19.18 119.51,19.18 | 119.51,19.18 115.32,19.18 115.06,18.92 115.06,18.41 114.68,18.41 114.68,18.33 R32.2 | R30.1 113.16,18.29 R32.2 | R32.2 114.72,18.29
N$70
  Top 0.203: 110.89,25.63 110.89,25.59 C18.2 110.87,25.49 110.87,25.65 | 110.87,25.65 111,25.65 | 110.87,25.65 110.87,26.7 111.17,27 U9.6
N$74  (via drill 0.25)
  Top 0.203: R56.2 109.6,5.84 109.6,5.46 112.78,5.46 | 112.78,5.46 v112.78,5.33 | 112.78,5.46 113.03,5.46 113.16,5.59 U21.9 | U12.1 112.06,12.99 v112.27,13.21
  Bottom 0.203: v112.27,13.21 112.27,10.16 113.28,9.14 113.28,5.46 113.16,5.33 v112.78,5.33
RESETB  (via drill 0.25)
  Top 0.203: SW1.SW1 14.73,18.92 | v54.23,29.46 U10.B4 | v46.1,22.48 46.1,27.94 46.35,28.19 v46.35,30.1 | v54.23,21.84 U10.H4 | v13.84,17.53 13.84,18.88 SW1.SW1 | SW1.SW1 13.84,18.97 | v52.96,26.92 U10.D2 | C22.1 14.22,19.26 SW1.SW1
  Route15 0.203: v108.08,18.03 105.66,20.45 104.39,20.45 103.63,19.68 103.63,16.38 103.38,16.13 97.66,16.13 96.52,17.27 92.71,17.27 91.95,16.51 77.85,16.51 77.09,17.27 71.88,17.27 68.71,20.45 64.52,20.45 63.75,21.21 62.36,21.21 61.09,22.48 57.66,22.48 56.39,21.21 U10.H4 v54.23,21.84 54.23,21.72 48.01,21.72 47.24,22.48 v46.1,22.48 45.59,22.48 43.81,20.7 43.81,18.92 43.43,18.54 36.7,18.54 35.05,16.89 25.4,16.89 24.13,15.62 16,15.62 14.1,17.53 v13.84,17.53 | v54.23,29.46 53.59,30.1 v46.35,30.1
  Bottom 0.203: 107.57,18.03 107.57,17.14 108.08,16.64 111.51,16.64 112.39,17.53 114.05,17.53 114.05,15.75 113.92,15.62 112.65,15.62 112.52,15.49 112.52,14.99 112.39,14.86 111.51,14.86 111.38,14.73 111.38,12.83 111.89,12.32 111.89,5.08 112.25,4.71 112.27,4.69 JP2.7 | 107.57,18.03 107.57,21.21 107.82,21.46 107.82,31.88 109.09,31.88 111.38,34.16 111.38,37.34 112.27,38.23 JP1.7 | v108.08,18.03 107.57,18.03 | TP22.TP 9.27,6.6 7.24,6.6 6.86,6.99 6.48,7.37 6.48,15.37 7.37,16.26 9.91,16.26 11.18,17.53 v13.84,17.53 | v52.96,26.92 53.59,27.56 54.86,27.56 U10.B4 v54.23,29.46
RUN_CH0  (via drill 0.25)
  Top 0.203: U1.1 16.38,33.78 16.44,33.73 16.44,32.33 VSNSN1.1 | v58.04,26.92 U10.D7
  Route15 0.203: v58.04,26.92 56.9,28.19 56.77,28.32 55.37,28.32 54.86,28.83 54.86,30.1 54.1,30.86 17.27,30.86 16.51,31.62 VSNSN1.1
  Bottom 0.203: R126.1 12.48,38.77 11.81,38.1 11.81,35.94 12.19,35.56 15.62,35.56 16.51,34.67 VSNSN1.1
  Bottom 0.406: Q17.1 12.23,42.02 12.19,41.91 12.19,40.39 R126.1
RUN_CH1  (via drill 0.25)
  Top 0.203: U2.1 27.94,33.78 28,33.73 28,32.33 VSNSN2.1 v28.07,28.45 | v59.31,24.38 U10.F8
  Route15 0.203: v59.31,24.38 58.67,23.75 56.9,23.75 56.13,24.51 47.24,24.51 47.12,24.64 44.7,24.64 40.51,28.83 28.07,28.83 v28.07,28.45
  Bottom 0.203: R125.1 24.04,38.77 23.37,38.1 23.37,35.94 23.75,35.56 27.18,35.56 28.07,34.67 VSNSN2.1
  Bottom 0.406: Q16.1 23.79,42.02 23.75,41.91 23.75,40.39 R125.1
RUN_CH2  (via drill 0.25)
  Top 0.203: U3.1 39.5,33.78 39.55,33.73 39.55,32.33 VSNSN3.1 39.62,27.05 v39.37,27.05 | v59.31,25.65 U10.E8
  Route2 0.203: v59.31,25.65 58.67,26.29 50.67,26.29 50.04,26.92 39.37,26.92 v39.37,27.05
  Bottom 0.203: R124.1 35.6,38.77 34.92,38.1 34.92,35.94 35.31,35.56 38.73,35.56 39.62,34.67 VSNSN3.1
  Bottom 0.406: Q15.1 35.34,42.02 35.31,41.91 35.31,40.39 R124.1
RUN_CH3  (via drill 0.25)
  Top 0.203: U4.1 51.05,33.78 51.11,33.73 51.11,32.33 VSNSN4.1 | v60.58,26.92 U10.D8
  Bottom 0.203: R123.1 47.16,38.77 46.48,38.1 46.48,35.94 46.86,35.56 50.29,35.56 51.18,34.67 VSNSN4.1 51.18,31.24 51.56,30.86 56.9,30.86 56.9,28.96 58.29,27.56 59.94,27.56 v60.58,26.92
  Bottom 0.406: Q14.1 46.9,42.02 46.86,41.91 46.86,40.39 R123.1
RUN_CH4  (via drill 0.25)
  Top 0.203: U5.1 62.61,33.78 62.67,33.73 62.67,32.33 VSNSN5.1 62.74,31.5 62.1,30.86 v61.85,30.86 | U10.C8 v59.31,28.19
  Bottom 0.203: R122.1 58.71,38.77 58.04,38.1 58.04,35.94 58.42,35.56 61.85,35.56 62.74,34.67 VSNSN5.1 | v59.31,28.19 58.67,28.83 57.66,28.83 57.4,29.08 57.4,30.86 v61.85,30.86
  Bottom 0.406: Q13.1 58.46,42.02 58.42,41.91 58.42,40.39 R122.1
RUN_CH5  (via drill 0.25)
  Top 0.203: U6.1 74.17,33.78 74.22,33.73 74.22,32.33 VSNSN6.1 v74.3,29.46 | U10.B8 v60.58,28.19
  Bottom 0.203: R121.1 70.27,38.77 69.6,38.1 69.6,35.94 69.98,35.56 73.41,35.56 74.3,34.67 VSNSN6.1 | 61.85,29.46 v60.58,28.19 61.98,29.59 74.3,29.59 v74.3,29.46
  Bottom 0.406: Q12.1 70.02,42.02 69.98,41.91 69.98,40.39 R121.1
RUN_CH6  (via drill 0.25)
  Top 0.203: U7.1 85.72,33.78 85.78,33.73 85.78,32.33 VSNSN7.1 v85.85,30.1 | U10.A8 v60.58,29.46
  Route15 0.203: v60.58,29.46 60.58,29.34 73.15,29.34 73.91,30.1 v85.85,30.1
  Bottom 0.203: R120.1 81.83,38.77 81.15,38.1 81.15,35.94 81.53,35.56 84.96,35.56 85.85,34.67 VSNSN7.1
  Bottom 0.406: Q11.1 81.57,42.02 81.53,41.91 81.53,40.39 R120.1
RUN_CH7  (via drill 0.25)
  Top 0.203: U8.1 97.28,33.78 97.34,33.73 97.34,32.33 VSNSN8.1 v97.41,29.59 | U10.C7 v59.31,26.92
  Route15 0.203: v59.31,26.92 59.69,26.92 61.59,25.02 65.28,25.02 66.8,26.54 68.2,26.54 69.22,27.56 79.25,27.56 80.64,28.96 90.93,28.96 91.82,29.84 97.41,29.84 v97.41,29.59
  Bottom 0.203: R119.1 93.38,38.77 92.71,38.1 92.71,35.94 93.09,35.56 96.52,35.56 97.41,34.67 VSNSN8.1
  Bottom 0.406: Q10.1 93.13,42.02 93.09,41.91 93.09,40.39 R119.1
RUN_CH8  (via drill 0.25)
  Top 0.203: U13.1 18.8,12.57 18.74,12.63 18.74,14.03 VSNSN9.1 | v58.04,19.3 U10.K7
  Route15 0.203: v58.04,19.3 57.4,18.67 46.35,18.67 45.47,17.78 37.21,17.78 35.56,16.13 25.91,16.13 24.64,14.86 18.92,14.86 18.67,14.61 VSNSN9.1
  Bottom 0.203: R81.1 22.69,7.58 23.37,8.26 23.37,10.41 22.99,10.79 19.56,10.79 18.67,11.68 VSNSN9.1
  Bottom 0.406: Q8.1 22.95,4.33 22.99,4.45 22.99,5.97 R81.1
RUN_CH9  (via drill 0.25)
  Top 0.203: U14.1 30.42,14.03 30.35,14.1 VSNSN10.1 | v59.31,15.49 U10.M8
  Route15 0.203: VSNSN10.1 30.23,14.48 30.61,14.86 57.15,14.86 57.91,14.1 57.91,13.72 58.29,13.34 60.07,13.34 60.45,13.72 60.45,14.48 59.44,15.49 v59.31,15.49
  Bottom 0.203: R80.1 34.25,7.58 34.92,8.26 34.92,10.41 34.54,10.79 31.11,10.79 30.23,11.68 VSNSN10.1
  Bottom 0.406: Q7.1 34.51,4.33 34.54,4.45 34.54,5.97 R80.1
RUN_CH10  (via drill 0.25)
  Top 0.203: U15.1 41.98,14.03 41.91,14.1 VSNSN11.1 42.04,14.1 42.29,14.35 v42.29,16.26 | v60.58,18.03 U10.L8
  Bottom 0.203: R79.1 45.81,7.58 46.48,8.26 46.48,10.41 46.1,10.79 42.67,10.79 42.16,11.3 42.16,13.72 VSNSN11.1 | v60.58,18.03 60.58,17.4 59.31,16.13 57.78,16.13 57.4,15.75 50.04,15.75 49.66,15.37 42.29,15.37 v42.29,16.26
  Bottom 0.406: Q6.1 46.06,4.33 46.1,4.45 46.1,5.97 R79.1
RUN_CH11  (via drill 0.25)
  Top 0.178: v54.23,18.03 54.23,15.8 53.34,14.91 VSNSN12.1
  Top 0.203: U16.1 53.54,14.03 53.47,14.1 VSNSN12.1 | v59.31,18.03 U10.K8
  Route15 0.203: v59.31,18.03 58.93,18.03 58.17,17.27 54.99,17.27 v54.23,18.03
  Bottom 0.203: R78.1 57.37,7.58 58.04,8.26 58.04,10.41 57.66,10.79 54.23,10.79 53.34,11.68 VSNSN12.1
  Bottom 0.406: Q5.1 57.62,4.33 57.66,4.45 57.66,5.97 R78.1
RUN_CH12  (via drill 0.25)
  Top 0.203: U17.1 65.09,14.03 65.02,14.1 VSNSN13.1 | v60.58,19.3 U10.J8
  Bottom 0.203: R77.1 68.92,7.58 69.6,8.26 69.6,10.41 69.22,10.79 65.79,10.79 64.9,11.68 VSNSN13.1 64.9,14.22 65.53,14.86 66.29,14.86 67.18,15.75 67.18,16.38 66.55,17.02 66.55,18.29 66.17,18.67 61.47,18.67 60.83,19.3 v60.58,19.3
  Bottom 0.406: Q4.1 69.18,4.33 69.22,4.45 69.22,5.97 R77.1
RUN_CH13  (via drill 0.25)
  Top 0.203: U18.1 76.65,14.03 76.58,14.1 VSNSN14.1 76.45,15.24 76.2,15.49 v76.2,15.88 | U10.H8 v60.58,20.57
  Route15 0.203: v60.58,20.57 61.21,19.94 61.21,19.05 61.59,18.67 67.94,18.67 68.33,18.29 68.33,15.88 68.58,15.62 76.2,15.62 v76.2,15.88
  Bottom 0.203: R76.1 80.48,7.58 81.15,8.26 81.15,10.41 80.77,10.79 77.34,10.79 76.45,11.68 VSNSN14.1
  Bottom 0.406: Q3.1 80.73,4.33 80.77,4.45 80.77,5.97 R76.1
RUN_CH14  (via drill 0.25)
  Top 0.203: U19.1 88.21,14.03 88.14,14.1 VSNSN15.1 v88.01,17.14 | U10.G8 v60.58,23.11
  Route15 0.203: v60.58,23.11 61.21,23.11 62.61,21.72 63.88,21.72 64.39,21.21 68.58,21.21 72.14,17.65 77.34,17.65 78.11,16.89 88.01,16.89 v88.01,17.14
  Bottom 0.203: R75.1 92.04,7.58 92.71,8.26 92.71,10.41 92.33,10.79 88.9,10.79 88.01,11.68 VSNSN15.1
  Bottom 0.406: Q2.1 92.29,4.33 92.33,4.45 92.33,5.97 R75.1
RUN_CH15  (via drill 0.25)
  Top 0.203: U20.1 99.77,14.03 99.69,14.1 VSNSN16.1 | U10.J7 v59.31,19.3
  Route15 0.203: v65.91,17.4 66.42,17.4 67.31,16.51 67.31,15.11 67.56,14.86 98.93,14.86 VSNSN16.1
  Bottom 0.203: R74.1 103.59,7.58 104.27,8.26 104.27,10.41 103.89,10.79 100.46,10.79 99.57,11.68 VSNSN16.1 | v65.91,17.4 62.1,17.4 60.83,18.67 59.94,18.67 v59.31,19.3
  Bottom 0.406: Q1.1 103.85,4.33 103.89,4.45 103.89,5.97 R74.1
SCL  (via drill 0.25)
  Top 0.203: U10.D1 50.29,25.53 50.29,25.02 50.04,24.77 48.01,24.77 v48.01,26.29 48.01,22.61 48.13,22.48 48.13,19.3 v47.88,19.3 | U10.K2 U10.K1 v50.42,19.3 | v20.45,30.23 v20.45,28.83 | U12.2 110.42,13.64 110.11,13.34 109.22,13.34 108.58,13.97 108.58,15.37 108.46,15.49 98.3,15.49 96.9,16.89 95.76,16.89 94.36,15.49 v93.85,15.49
  Route15 0.203: v47.88,19.3 v50.42,19.3 | v20.45,28.83 20.7,29.08 22.23,29.08 22.86,29.72 41.53,29.72 44.2,27.05 46.48,27.05 47.24,26.29 v48.01,26.29 | TP13.TP 9.27,30.86 9.91,30.23 v20.45,30.23
  Bottom 0.203: v93.85,15.49 93.85,15.11 93.6,14.86 68.71,14.86 68.33,15.24 68.33,18.41 66.8,19.94 62.87,19.94 61.21,21.59 59.94,21.59 59.31,20.95 57.28,20.95 56.26,19.94 51.05,19.94 v50.42,19.3
SCL_IN  (via drill 0.25)
  Top 0.203: U12.3 110.83,14.22 113.28,14.22 | J2.4 129.24,17.64 128.34,16.74 126.56,16.74 125.95,16.13 113.28,16.13 | 113.28,14.22 113.28,13.21 112.14,12.06 112.14,11.02 U21.19 | v111.89,15.62 111.89,15.88 112.14,16.13 113.28,16.13 | 113.28,16.13 113.28,14.22
  Bottom 0.203: 111,16.26 107.7,16.26 107.06,16.89 107.06,21.46 107.44,21.84 107.44,32.26 108.84,32.26 110.87,34.29 110.87,37.59 111.28,37.95 111.28,40.12 JP1.6 | 111,16.26 111,12.45 111.51,11.94 111.51,5.08 111.28,4.85 111.28,2.18 110.87,1.78 110.31,1.78 110.31,1.72 JP2.6 | 111,16.26 111.89,16.26 | 111.89,16.26 112.27,16.64 R99.2 | 111.89,16.26 v111.89,15.62
SDA  (via drill 0.25)
  Top 0.203: 106.17,13.59 105.78,13.59 | U10.C1 v46.99,27.56 46.99,26.42 47.37,26.04 47.37,25.4 47.12,25.15 v47.12,20.32 | v51.69,19.3 51.69,19.94 | 51.69,19.94 U10.J2 | 51.69,19.94 U10.J1 | U12.7 106.12,13.64 106.17,13.59 | 106.17,13.59 107.19,13.59 v107.19,13.34
  Route15 0.203: v47.12,20.32 47.12,19.94 U10.J1 v51.69,19.3 | TP14.TP 9.27,29.21 9.91,29.84 19.68,29.84 19.94,29.59 22.1,29.59 22.61,30.1 41.78,30.1 44.32,27.56 v46.99,27.56 | v107.19,13.34 105.41,15.24 95.5,15.24 94.61,16.13 93.47,16.13 92.58,15.24 67.94,15.24 67.69,15.49 67.69,17.91 v67.56,18.03
  Bottom 0.203: v67.56,18.03 67.44,18.03 66.29,19.18 62.99,19.18 60.96,21.21 60.2,21.21 59.56,20.57 57.66,20.57 56.39,19.3 v51.69,19.3
SDA_IN  (via drill 0.25)
  Top 0.203: U21.20 111.65,12.05 111.38,12.32 109.6,12.32 108.2,13.72 108.2,14.22 108.08,14.35 v107.19,14.35 106.18,14.35 U12.6 | 112.27,16.64 125.7,16.64 126.08,17.02 126.08,20.45 126.46,20.83 129,20.83 129.27,20.56 J2.2 | v109.47,13.97 109.22,13.97 108.97,14.22 108.97,16.26 109.35,16.64 112.27,16.64 | 112.27,16.64 112.27,19.05 112.01,19.3 v112.01,19.68
  Bottom 0.203: JP2.4 109.27,2.72 109.27,6.81 110.36,8 110.36,11.05 109.47,11.94 v109.47,13.97 107.57,13.97 v107.19,14.35 106.3,15.24 106.3,19.94 105.41,20.83 105.41,33.27 105.66,33.53 105.66,36.32 107.06,37.72 109.09,37.72 109.27,37.9 109.27,40.08 108.25,41.1 108.25,41.13 JP1.4
  Bottom 0.254: v112.01,19.68 112.52,19.68 112.9,19.3 112.9,18.41 R100.2
SHARE_CLK  (via drill 0.25)
  Top 0.178: v52.96,29.46 52.96,30.86
  Top 0.203: v52.96,29.46 U10.B2 | v44.07,29.46 44.07,25.27 44.83,24.51 v44.83,19.18 44.83,16.73 R36.1 | v51.69,20.57 U10.H2 | 52.96,30.86 53.47,31.37 61.21,31.37 61.72,31.88 v61.72,32.13
  Route15 0.203: v44.07,29.46 v52.96,29.46 | v44.83,19.18 44.83,20.32 45.72,21.21 47.24,21.21 47.88,20.57 v51.69,20.57 | v61.72,32.13 61.72,31.88 62.23,31.37 65.91,31.37 67.18,30.1 72.39,30.1 73.41,31.11 86.74,31.11 87,31.37 91.44,31.37 91.95,30.86 100.97,30.86 101.6,31.5 103,31.5 103.5,32 106.3,32 106.3,33.78 TP11.TP | 109.27,2.72 | 109.27,2.72 107.31,2.72 v107.31,2.54 | JP2.5 109.27,2.72
  Bottom 0.203: 110.36,35.43 110.36,37.59 110.24,37.72 110.24,39.12 110.25,39.13 JP1.5 | JP2.5 110.25,3.72 110.25,7 110.74,7.49 110.74,11.3 110.24,11.81 110.24,14.22 109.73,14.73 107.82,14.73 106.68,15.88 106.68,21.72 107.06,22.1 107.06,32.64 108.58,32.64 110.36,34.42 110.36,35.43 | TP11.TP 110.36,35.43 | JP3.5 106.88,5.13 107.26,4.75 107.26,2.54 v107.31,2.54
SW1
  pour Top (no thermals): 22.1,33.02 17.91,33.02 17.91,34.67 22.1,34.67
SW2
  pour Top (no thermals): 33.66,33.02 29.46,33.02 29.46,34.67 33.66,34.67
SW3
  pour Top (no thermals): 45.21,33.02 41.02,33.02 41.02,34.67 45.21,34.67
SW4
  pour Top (no thermals): 56.77,33.02 52.58,33.02 52.58,34.67 56.77,34.67
SW5
  pour Top (no thermals): 68.33,33.02 64.14,33.02 64.14,34.67 68.33,34.67
SW6
  pour Top (no thermals): 79.88,33.02 75.69,33.02 75.69,34.67 79.88,34.67
SW7
  pour Top (no thermals): 91.44,33.02 87.25,33.02 87.25,34.67 91.44,34.67
SW8
  pour Top (no thermals): 103,33.02 98.81,33.02 98.81,34.67 103,34.67
SW11
  pour Top (no thermals): 13.08,13.34 17.27,13.34 17.27,11.68 13.08,11.68
SW12
  pour Top (no thermals): 24.64,13.34 28.83,13.34 28.83,11.68 24.64,11.68
SW13
  pour Top (no thermals): 36.2,13.34 40.39,13.34 40.39,11.68 36.2,11.68
SW14
  pour Top (no thermals): 47.75,13.34 51.94,13.34 51.94,11.68 47.75,11.68
SW15
  pour Top (no thermals): 59.31,13.34 63.5,13.34 63.5,11.68 59.31,11.68
SW16
  pour Top (no thermals): 70.87,13.34 75.06,13.34 75.06,11.68 70.87,11.68
SW17
  pour Top (no thermals): 82.42,13.34 86.61,13.34 86.61,11.68 82.42,11.68
SW18
  pour Top (no thermals): 93.98,13.34 98.17,13.34 98.17,11.68 93.98,11.68
SW_LTC3604
  Top 0.203: 109.16,25.37 C18.1
  pour Top (no thermals): 105.54,28.83 107.95,28.83 108.84,27.94 108.84,24.89 110.36,24.89 110.36,28.96 109.35,28.96 109.35,32 105.54,32
UNUSED1
  Route15 0.203: JP1.9 114.27,38.39 114.55,38.1 120.78,38.1 121.41,38.73 129.51,38.73 130.05,38.2 130.05,21.21 129.67,20.83 129.54,20.83 126.49,20.83 125.98,20.32 125.98,10.29 123.95,8.26 123.95,6.99 123.57,6.6 114.94,6.6 114.3,5.97 114.3,3.75 JP2.9
UNUSED2  (via drill 0.25)
  Top 0.203: v115.27,5.16 115.27,2.71 JP2.10
  Route15 0.203: JP1.10 114.3,41.13 114.3,41.91 114.81,42.42 119.38,42.42 120.14,41.66 120.14,40.51 121.41,39.24 129.67,39.24 130.56,38.35 130.56,9.4 129.79,8.64 125.09,8.64 124.59,8.13 124.59,6.86 123.83,6.1 115.7,6.1 115.32,5.71 115.32,5.21 v115.27,5.16
VDD  (via drill 0.25)
  Top 0.203: v101.85,7.75 103,7.75 103,7.11 103.04,7.24 R46.2 | v90.3,7.75 91.44,7.75 91.44,7.11 91.48,7.24 R45.2 | v78.74,7.75 79.88,7.75 79.88,7.11 79.92,7.24 R44.2 | v67.18,7.75 68.33,7.75 68.33,7.11 68.36,7.24 R43.2 | v55.63,7.75 56.77,7.75 56.77,7.11 56.81,7.24 R42.2 | v44.07,7.75 45.21,7.75 45.21,7.11 45.25,7.24 R41.2 | v32.51,7.75 33.66,7.75 33.66,7.11 33.69,7.24 R40.2 | v20.95,7.75 22.1,7.75 22.1,7.11 22.14,7.24 R39.2 | U11.16 U11.15 119.4,26.44 119.51,26.54 121.79,26.54 121.92,26.42 121.92,25.22 U11.10 U11.9 | TP20.TP1 110.24,17.14 109.22,17.14 108.46,16.38 106.89,16.38 R35.2 | v14.22,38.61 13.08,38.61 13.08,39.24 13.04,39.12 R17.2 | v25.78,38.61 24.64,38.61 24.64,39.24 24.6,39.12 R18.2 | v37.34,38.61 36.2,38.61 36.2,39.24 36.16,39.12 R19.2 | v48.9,38.61 47.75,38.61 47.75,39.24 47.71,39.12 R20.2 | v60.45,38.61 59.31,38.61 59.31,39.24 59.27,39.12 R21.2 | v72.01,38.61 70.87,38.61 70.87,39.24 70.83,39.12 R22.2 | v83.57,38.61 82.42,38.61 82.42,39.24 82.38,39.12 R23.2 | v95.12,38.61 93.98,38.61 93.98,39.24 93.94,39.12 R24.2 | 56.13,29.46 U10.B5 | 56.13,29.46 U10.A5 | v55.5,29.46 56.13,29.46 | 56.13,21.84 U10.H5 | 56.13,21.84 U10.G5 | v55.5,21.84 56.13,21.84
  Top 0.254: SW2.SW2 v33.53,18.92
  Route15 0.203: v55.5,21.84 55.5,21.72
  Bottom 0.203: 101.85,5.97 R74.2 | R75.2 90.3,5.97 | 78.74,5.97 R76.2 | 67.18,5.97 R77.2 | R78.2 55.63,5.97 | 44.07,5.97 R79.2 | R80.2 32.51,5.97 | 20.95,5.97 R81.2 | 14.22,40.39 R126.2 | 25.78,40.39 R125.2 | 37.34,40.39 R124.2 | 48.9,40.39 R123.2 | 60.45,40.39 R122.2 | 72.01,40.39 R121.2 | 83.57,40.39 R120.2 | 95.12,40.39 R119.2
  Bottom 0.406: v101.85,7.75 101.85,5.97 | 90.3,5.97 v90.3,7.75 | v78.74,7.75 78.74,5.97 | v67.18,7.75 67.18,5.97 | 55.63,5.97 v55.63,7.75 | v44.07,7.75 44.07,5.97 | 32.51,5.97 v32.51,7.75 | v20.95,7.75 20.95,5.97 | v14.22,38.61 14.22,40.39 | v25.78,38.61 25.78,40.39 | v37.34,38.61 37.34,40.39 | v48.9,38.61 48.9,40.39 | v60.45,38.61 60.45,40.39 | v72.01,38.61 72.01,40.39 | v83.57,38.61 83.57,40.39 | v95.12,38.61 95.12,40.39
  other vias: 102.74,4.45 91.19,4.45 79.63,4.45 68.07,4.45 56.52,4.45 44.96,4.45 33.4,4.45 21.84,4.45 124.33,26.8 123.32,26.8 124.33,25.53 123.32,25.53 124.33,24.26 13.34,41.91 24.89,41.91 36.45,41.91 48.01,41.91 59.56,41.91 71.12,41.91 82.68,41.91 94.23,41.91
  pour Top (no thermals): 97.54,10.67 98.17,10.67 98.17,9.14 98.42,8.89 99.19,8.89 99.44,9.14 99.44,10.67 104.01,10.67 104.01,6.86 102.49,6.86 102.23,6.6 102.23,5.21 102.49,4.95 103.25,4.95 103.25,4.06 101.22,4.06 101.22,6.99 100.08,8.13 98.3,8.13 97.54,8.89
  pour Top (no thermals): 85.98,10.67 86.61,10.67 86.61,9.14 86.87,8.89 87.63,8.89 87.88,9.14 87.88,10.67 92.46,10.67 92.46,6.86 90.93,6.86 90.68,6.6 90.68,5.21 90.93,4.95 91.69,4.95 91.69,4.06 89.66,4.06 89.66,6.99 88.52,8.13 86.74,8.13 85.98,8.89
  pour Top (no thermals): 74.42,10.67 75.06,10.67 75.06,9.14 75.31,8.89 76.07,8.89 76.33,9.14 76.33,10.67 80.9,10.67 80.9,6.86 79.38,6.86 79.12,6.6 79.12,5.21 79.38,4.95 80.14,4.95 80.14,4.06 78.11,4.06 78.11,6.99 76.96,8.13 75.18,8.13 74.42,8.89
  pour Top (no thermals): 62.87,10.67 63.5,10.67 63.5,9.14 63.75,8.89 64.52,8.89 64.77,9.14 64.77,10.67 69.34,10.67 69.34,6.86 67.82,6.86 67.56,6.6 67.56,5.21 67.82,4.95 68.58,4.95 68.58,4.06 66.55,4.06 66.55,6.99 65.41,8.13 63.63,8.13 62.87,8.89
  pour Top (no thermals): 51.31,10.67 51.94,10.67 51.94,9.14 52.2,8.89 52.96,8.89 53.21,9.14 53.21,10.67 57.78,10.67 57.78,6.86 56.26,6.86 56.01,6.6 56.01,5.21 56.26,4.95 57.02,4.95 57.02,4.06 54.99,4.06 54.99,6.99 53.85,8.13 52.07,8.13 51.31,8.89
  pour Top (no thermals): 39.75,10.67 40.39,10.67 40.39,9.14 40.64,8.89 41.4,8.89 41.66,9.14 41.66,10.67 46.23,10.67 46.23,6.86 44.7,6.86 44.45,6.6 44.45,5.21 44.7,4.95 45.47,4.95 45.47,4.06 43.43,4.06 43.43,6.99 42.29,8.13 40.51,8.13 39.75,8.89
  pour Top (no thermals): 28.19,10.67 28.83,10.67 28.83,9.14 29.08,8.89 29.84,8.89 30.1,9.14 30.1,10.67 34.67,10.67 34.67,6.86 33.15,6.86 32.89,6.6 32.89,5.21 33.15,4.95 33.91,4.95 33.91,4.06 31.88,4.06 31.88,6.99 30.73,8.13 28.96,8.13 28.19,8.89
  pour Top (no thermals): 16.64,10.67 17.27,10.67 17.27,9.14 17.53,8.89 18.29,8.89 18.54,9.14 18.54,10.67 23.11,10.67 23.11,6.86 21.59,6.86 21.34,6.6 21.34,5.21 21.59,4.95 22.35,4.95 22.35,4.06 20.32,4.06 20.32,6.99 19.18,8.13 17.4,8.13 16.64,8.89
  pour Route15 (no thermals): 0.89,45.59 0.89,2.29 2.41,0.76 2.79,0.76 130.65,0.76 130.65,45.59
  pour Top (no thermals): 118.75,27.18 126.62,27.18 126.62,23.88 124.08,23.88 123.32,24.64 121.92,24.64 121.92,26.16 119.38,26.16 119.38,24.64 118.75,24.64
  pour Top (no thermals): 18.54,35.69 17.91,35.69 17.91,37.21 17.65,37.47 16.89,37.47 16.64,37.21 16.64,35.69 12.19,35.69 12.19,39.5 13.59,39.5 13.84,39.75 13.84,41.15 13.59,41.4 12.83,41.4 12.83,42.29 14.86,42.29 14.86,39.37 16,38.23 17.78,38.23 18.54,37.47
  pour Top (no thermals): 30.1,35.69 29.46,35.69 29.46,37.21 29.21,37.47 28.45,37.47 28.19,37.21 28.19,35.69 23.62,35.69 23.62,39.5 25.15,39.5 25.4,39.75 25.4,41.15 25.15,41.4 24.38,41.4 24.38,42.29 26.42,42.29 26.42,39.37 27.56,38.23 29.34,38.23 30.1,37.47
  pour Top (no thermals): 41.66,35.69 41.02,35.69 41.02,37.21 40.77,37.47 40.01,37.47 39.75,37.21 39.75,35.69 35.18,35.69 35.18,39.5 36.7,39.5 36.96,39.75 36.96,41.15 36.7,41.4 35.94,41.4 35.94,42.29 37.97,42.29 37.97,39.37 39.12,38.23 40.89,38.23 41.66,37.47
  pour Top (no thermals): 53.21,35.69 52.58,35.69 52.58,37.21 52.32,37.47 51.56,37.47 51.31,37.21 51.31,35.69 46.74,35.69 46.74,39.5 48.26,39.5 48.51,39.75 48.51,41.15 48.26,41.4 47.5,41.4 47.5,42.29 49.53,42.29 49.53,39.37 50.67,38.23 52.45,38.23 53.21,37.47
  pour Top (no thermals): 64.77,35.69 64.14,35.69 64.14,37.21 63.88,37.47 63.12,37.47 62.87,37.21 62.87,35.69 58.29,35.69 58.29,39.5 59.82,39.5 60.07,39.75 60.07,41.15 59.82,41.4 59.05,41.4 59.05,42.29 61.09,42.29 61.09,39.37 62.23,38.23 64.01,38.23 64.77,37.47
  pour Top (no thermals): 76.33,35.69 75.69,35.69 75.69,37.21 75.44,37.47 74.68,37.47 74.42,37.21 74.42,35.69 69.85,35.69 69.85,39.5 71.37,39.5 71.63,39.75 71.63,41.15 71.37,41.4 70.61,41.4 70.61,42.29 72.64,42.29 72.64,39.37 73.79,38.23 75.56,38.23 76.33,37.47
  pour Top (no thermals): 87.88,35.69 87.25,35.69 87.25,37.21 87,37.47 86.23,37.47 85.98,37.21 85.98,35.69 81.41,35.69 81.41,39.5 82.93,39.5 83.19,39.75 83.19,41.15 82.93,41.4 82.17,41.4 82.17,42.29 84.2,42.29 84.2,39.37 85.34,38.23 87.12,38.23 87.88,37.47
  pour Top (no thermals): 99.44,35.69 98.81,35.69 98.81,37.21 98.55,37.47 97.79,37.47 97.54,37.21 97.54,35.69 92.96,35.69 92.96,39.5 94.49,39.5 94.74,39.75 94.74,41.15 94.49,41.4 93.73,41.4 93.73,42.29 95.76,42.29 95.76,39.37 96.9,38.23 98.68,38.23 99.44,37.47
VFB1  (via drill 0.25)
  Top 0.203: U1.5 17.27,35.56 17.65,35.18 22.61,35.18 | 22.61,40.09 22.61,40.13 | 22.61,35.18 22.61,40.09 | v22.99,34.42 22.99,35.18 22.61,35.18 | 22.61,40.09 R9.2
  Top 0.254: R9.2 22.57,40.39
  Top 0.406: 22.57,40.39 C1.2 22.61,41.91 22.61,43.05 R1.1
  Bottom 0.203: v22.99,34.42 22.99,34.92 22.61,35.31 21.97,35.31 21.97,35.69 R117.1
VFB2  (via drill 0.25)
  Top 0.203: U2.5 28.83,35.56 29.21,35.18 34.16,35.18 | 34.16,40.09 34.16,40.13 | 34.16,35.18 34.16,40.09 | v34.54,34.42 34.54,35.18 34.16,35.18 | 34.16,40.09 R10.2
  Top 0.254: R10.2 34.12,40.39
  Top 0.406: 34.12,40.39 C2.2 34.16,41.91 34.16,43.05 R2.1
  Bottom 0.203: v34.54,34.42 34.54,34.92 34.16,35.31 33.53,35.31 33.53,35.69 R115.1
VFB3  (via drill 0.25)
  Top 0.203: U3.5 40.39,35.56 40.77,35.18 45.72,35.18 | 45.72,40.09 45.72,40.13 | 45.72,35.18 45.72,40.09 | v46.1,34.42 46.1,35.18 45.72,35.18 | 45.72,40.09 R11.2
  Top 0.254: R11.2 45.68,40.39
  Top 0.406: 45.68,40.39 C3.2 45.72,41.91 45.72,43.05 R3.1
  Bottom 0.203: v46.1,34.42 46.1,34.92 45.72,35.31 45.09,35.31 45.09,35.69 R113.1
VFB4  (via drill 0.25)
  Top 0.203: U13.5 17.91,10.79 17.53,11.18 12.57,11.18 | 12.57,6.26 12.57,6.22 | 12.57,6.26 12.57,11.18 | v12.19,11.94 12.19,11.18 12.57,11.18 | R48.2 12.57,6.26
  Top 0.254: 12.61,5.97 R48.2
  Top 0.406: 12.61,5.97 C38.2 12.57,4.45 12.57,3.3 R58.1
  Bottom 0.203: v12.19,11.94 12.19,11.43 12.57,11.05 13.21,11.05 13.21,10.67 R97.1
VFB5  (via drill 0.25)
  Top 0.203: U14.5 29.46,10.79 29.08,11.18 24.13,11.18 | 24.13,6.26 24.13,6.22 | 24.13,6.26 24.13,11.18 | v23.75,11.94 23.75,11.18 24.13,11.18 | R49.2 24.13,6.26
  Top 0.254: 24.17,5.97 R49.2
  Top 0.406: 24.17,5.97 C39.2 24.13,4.45 24.13,3.3 R59.1
  Bottom 0.203: v23.75,11.94 23.75,11.43 24.13,11.05 24.77,11.05 24.77,10.67 R95.1
VFB6  (via drill 0.25)
  Top 0.203: U15.5 41.02,10.79 40.64,11.18 35.69,11.18 | 35.69,6.26 35.69,6.22 | 35.69,6.26 35.69,11.18 | v35.31,11.94 35.31,11.18 35.69,11.18 | R50.2 35.69,6.26
  Top 0.254: 35.73,5.97 R50.2
  Top 0.406: 35.73,5.97 C40.2 35.69,4.45 35.69,3.3 R60.1
  Bottom 0.203: v35.31,11.94 35.31,11.43 35.69,11.05 36.32,11.05 36.32,10.67 R93.1
VFB7  (via drill 0.25)
  Top 0.203: U16.5 52.58,10.79 52.2,11.18 47.24,11.18 | 47.24,6.26 47.24,6.22 | 47.24,6.26 47.24,11.18 | v46.86,11.94 46.86,11.18 47.24,11.18 | R51.2 47.24,6.26
  Top 0.254: 47.28,5.97 R51.2
  Top 0.406: 47.28,5.97 C41.2 47.24,4.45 47.24,3.3 R61.1
  Bottom 0.203: v46.86,11.94 46.86,11.43 47.24,11.05 47.88,11.05 47.88,10.67 R91.1
VFB8  (via drill 0.25)
  Top 0.203: U17.5 64.14,10.79 63.75,11.18 58.8,11.18 | 58.8,6.26 58.8,6.22 | 58.8,6.26 58.8,11.18 | v58.42,11.94 58.42,11.18 58.8,11.18 | R52.2 58.8,6.26
  Top 0.254: 58.84,5.97 R52.2
  Top 0.406: 58.84,5.97 C42.2 58.8,4.45 58.8,3.3 R62.1
  Bottom 0.203: v58.42,11.94 58.42,11.43 58.8,11.05 59.44,11.05 59.44,10.67 R89.1
VFB9  (via drill 0.25)
  Top 0.203: U18.5 75.69,10.79 75.31,11.18 70.36,11.18 | 70.36,6.26 70.36,6.22 | 70.36,6.26 70.36,11.18 | v69.98,11.94 69.98,11.18 70.36,11.18 | R53.2 70.36,6.26
  Top 0.254: 70.4,5.97 R53.2
  Top 0.406: 70.4,5.97 C43.2 70.36,4.45 70.36,3.3 R63.1
  Bottom 0.203: v69.98,11.94 69.98,11.43 70.36,11.05 70.99,11.05 70.99,10.67 R87.1
VFB10  (via drill 0.25)
  Top 0.203: U19.5 87.25,10.79 86.87,11.18 81.92,11.18 | 81.92,6.26 81.92,6.22 | 81.92,6.26 81.92,11.18 | v81.53,11.94 81.53,11.18 81.92,11.18 | R54.2 81.92,6.26
  Top 0.254: 81.95,5.97 R54.2
  Top 0.406: 81.95,5.97 C44.2 81.92,4.45 81.92,3.3 R64.1
  Bottom 0.203: v81.53,11.94 81.53,11.43 81.92,11.05 82.55,11.05 82.55,10.67 R85.1
VFB11  (via drill 0.25)
  Top 0.203: U20.5 98.81,10.79 98.42,11.18 93.47,11.18 | 93.47,6.26 93.47,6.22 | 93.47,6.26 93.47,11.18 | v93.09,11.94 93.09,11.18 93.47,11.18 | R55.2 93.47,6.26
  Top 0.254: 93.51,5.97 R55.2
  Top 0.406: 93.51,5.97 C45.2 93.47,4.45 93.47,3.3 R65.1
  Bottom 0.203: v93.09,11.94 93.09,11.43 93.47,11.05 94.11,11.05 94.11,10.67 R83.1
VFB12  (via drill 0.25)
  Top 0.203: U4.5 51.94,35.56 52.32,35.18 57.28,35.18 | 57.28,40.09 57.28,40.13 | 57.28,35.18 57.28,40.09 | v57.66,34.42 57.66,35.18 57.28,35.18 | 57.28,40.09 R12.2
  Top 0.254: R12.2 57.24,40.39
  Top 0.406: 57.24,40.39 C4.2 57.28,41.91 57.28,43.05 R4.1
  Bottom 0.203: v57.66,34.42 57.66,34.92 57.28,35.31 56.64,35.31 56.64,35.69 R111.1
VFB13  (via drill 0.25)
  Top 0.203: U5.5 63.5,35.56 63.88,35.18 68.83,35.18 | 68.83,40.09 68.83,40.13 | 68.83,35.18 68.83,40.09 | v69.22,34.42 69.22,35.18 68.83,35.18 | 68.83,40.09 R13.2
  Top 0.254: R13.2 68.8,40.39
  Top 0.406: 68.8,40.39 C5.2 68.83,41.91 68.83,43.05 R5.1
  Bottom 0.203: v69.22,34.42 69.22,34.92 68.83,35.31 68.2,35.31 68.2,35.69 R109.1
VFB14  (via drill 0.25)
  Top 0.203: U6.5 75.06,35.56 75.44,35.18 80.39,35.18 | 80.39,40.09 80.39,40.13 | 80.39,35.18 80.39,40.09 | v80.77,34.42 80.77,35.18 80.39,35.18 | 80.39,40.09 R14.2
  Top 0.254: R14.2 80.35,40.39
  Top 0.406: 80.35,40.39 C6.2 80.39,41.91 80.39,43.05 R6.1
  Bottom 0.203: v80.77,34.42 80.77,34.92 80.39,35.31 79.76,35.31 79.76,35.69 R107.1
VFB15  (via drill 0.25)
  Top 0.203: U7.5 86.61,35.56 87,35.18 91.95,35.18 | 91.95,40.09 91.95,40.13 | 91.95,35.18 91.95,40.09 | v92.33,34.42 92.33,35.18 91.95,35.18 | 91.95,40.09 R15.2
  Top 0.254: R15.2 91.91,40.39
  Top 0.406: 91.91,40.39 C7.2 91.95,41.91 91.95,43.05 R7.1
  Bottom 0.203: v92.33,34.42 92.33,34.92 91.95,35.31 91.31,35.31 91.31,35.69 R105.1
VFB16  (via drill 0.25)
  Top 0.203: U8.5 98.17,35.56 98.55,35.18 103.5,35.18 | 103.5,40.09 103.5,40.13 | 103.5,35.18 103.5,40.09 | v103.76,34.8 103.76,35.18 103.5,35.18 | 103.5,40.09 R16.2
  Top 0.254: R16.2 103.47,40.39
  Top 0.406: 103.47,40.39 C8.2 103.5,41.91 103.5,43.05 R8.1
  Bottom 0.203: v103.76,34.8 103.76,35.05 103.5,35.31 102.87,35.31 102.87,35.69 R103.1
VOUT_CH0
  Top 0.254: R1.2 20.87,43.05 C1.1 17.4,41.91 TP3.TP
  pour Top (no thermals): 22.1,35.69 19.05,35.69 19.05,37.72 18.03,38.73 16.26,38.73 15.37,39.62 15.37,42.42 17.02,44.07 21.34,44.07 21.34,41.4 19.81,41.4 18.92,40.51 18.92,39.88 19.56,39.24 22.1,39.24
  pour Bottom (no thermals): 23.37,44.07 23.37,41.78 20.19,41.78 18.92,40.51 18.92,37.21 18.41,36.7 18.41,35.05 16.89,35.05 16,35.94 12.45,35.94 12.19,36.2 12.19,37.85 14.73,37.85 15.11,38.23 15.11,42.16 17.02,44.07
VOUT_CH1
  Top 0.254: R2.2 32.42,43.05 C2.1 28.96,41.91 TP4.TP
  pour Top (no thermals): 33.66,35.69 30.61,35.69 30.61,37.72 29.59,38.73 27.81,38.73 26.92,39.62 26.92,42.42 28.57,44.07 32.89,44.07 32.89,41.4 31.37,41.4 30.48,40.51 30.48,39.88 31.11,39.24 33.66,39.24
  pour Bottom (no thermals): 34.92,44.07 34.92,41.78 31.75,41.78 30.48,40.51 30.48,37.21 29.97,36.7 29.97,35.05 28.45,35.05 27.56,35.94 24,35.94 23.75,36.2 23.75,37.85 26.29,37.85 26.67,38.23 26.67,42.16 28.57,44.07
VOUT_CH2
  Top 0.254: R3.2 43.98,43.05 C3.1 40.51,41.91 TP5.TP
  pour Top (no thermals): 45.21,35.69 42.16,35.69 42.16,37.72 41.15,38.73 39.37,38.73 38.48,39.62 38.48,42.42 40.13,44.07 44.45,44.07 44.45,41.4 42.93,41.4 42.04,40.51 42.04,39.88 42.67,39.24 45.21,39.24
  pour Bottom (no thermals): 46.48,44.07 46.48,41.78 43.31,41.78 42.04,40.51 42.04,37.21 41.53,36.7 41.53,35.05 40.01,35.05 39.12,35.94 35.56,35.94 35.31,36.2 35.31,37.85 37.85,37.85 38.23,38.23 38.23,42.16 40.13,44.07
VOUT_CH3
  Top 0.254: R4.2 55.54,43.05 C4.1 52.07,41.91 TP6.TP
  pour Top (no thermals): 56.77,35.69 53.72,35.69 53.72,37.72 52.7,38.73 50.93,38.73 50.04,39.62 50.04,42.42 51.69,44.07 56.01,44.07 56.01,41.4 54.48,41.4 53.59,40.51 53.59,39.88 54.23,39.24 56.77,39.24
  pour Bottom (no thermals): 58.04,44.07 58.04,41.78 54.86,41.78 53.59,40.51 53.59,37.21 53.09,36.7 53.09,35.05 51.56,35.05 50.67,35.94 47.12,35.94 46.86,36.2 46.86,37.85 49.4,37.85 49.78,38.23 49.78,42.16 51.69,44.07
VOUT_CH4
  Top 0.254: R5.2 67.09,43.05 C5.1 63.63,41.91 TP7.TP
  pour Top (no thermals): 68.33,35.69 65.28,35.69 65.28,37.72 64.26,38.73 62.48,38.73 61.59,39.62 61.59,42.42 63.25,44.07 67.56,44.07 67.56,41.4 66.04,41.4 65.15,40.51 65.15,39.88 65.79,39.24 68.33,39.24
  pour Bottom (no thermals): 69.6,44.07 69.6,41.78 66.42,41.78 65.15,40.51 65.15,37.21 64.64,36.7 64.64,35.05 63.12,35.05 62.23,35.94 58.67,35.94 58.42,36.2 58.42,37.85 60.96,37.85 61.34,38.23 61.34,42.16 63.25,44.07
VOUT_CH5
  Top 0.254: R6.2 78.65,43.05 C6.1 75.18,41.91 TP8.TP
  pour Top (no thermals): 79.88,35.69 76.83,35.69 76.83,37.72 75.82,38.73 74.04,38.73 73.15,39.62 73.15,42.42 74.8,44.07 79.12,44.07 79.12,41.4 77.6,41.4 76.71,40.51 76.71,39.88 77.34,39.24 79.88,39.24
  pour Bottom (no thermals): 81.15,44.07 81.15,41.78 77.98,41.78 76.71,40.51 76.71,37.21 76.2,36.7 76.2,35.05 74.68,35.05 73.79,35.94 70.23,35.94 69.98,36.2 69.98,37.85 72.52,37.85 72.9,38.23 72.9,42.16 74.8,44.07
VOUT_CH6
  Top 0.254: R7.2 90.21,43.05 C7.1 86.74,41.91 TP9.TP
  pour Top (no thermals): 91.44,35.69 88.39,35.69 88.39,37.72 87.38,38.73 85.6,38.73 84.71,39.62 84.71,42.42 86.36,44.07 90.68,44.07 90.68,41.4 89.15,41.4 88.27,40.51 88.27,39.88 88.9,39.24 91.44,39.24
  pour Bottom (no thermals): 92.71,44.07 92.71,41.78 89.53,41.78 88.27,40.51 88.27,37.21 87.76,36.7 87.76,35.05 86.23,35.05 85.34,35.94 81.79,35.94 81.53,36.2 81.53,37.85 84.07,37.85 84.45,38.23 84.45,42.16 86.36,44.07
VOUT_CH7
  Top 0.254: R8.2 101.77,43.05 C8.1 98.3,41.91 TP10.TP
  pour Top (no thermals): 103,35.69 99.95,35.69 99.95,37.72 98.93,38.73 97.16,38.73 96.27,39.62 96.27,42.42 97.92,44.07 102.23,44.07 102.23,41.4 100.71,41.4 99.82,40.51 99.82,39.88 100.46,39.24 103,39.24
  pour Bottom (no thermals): 103.76,44.07 103.76,41.78 101.09,41.78 99.82,40.51 99.82,37.21 99.31,36.7 99.31,35.05 97.79,35.05 96.9,35.94 93.34,35.94 93.09,36.2 93.09,37.85 95.63,37.85 96.01,38.23 96.01,42.16 97.92,44.07
VOUT_CH8
  Top 0.254: R58.2 14.31,3.3 C38.1 17.78,4.45 TP23.TP
  pour Bottom (no thermals): 11.81,2.29 11.81,4.57 14.99,4.57 16.26,5.84 16.26,9.14 16.76,9.65 16.76,11.3 18.29,11.3 19.18,10.41 22.73,10.41 22.99,10.16 22.99,8.51 20.45,8.51 20.07,8.13 20.07,4.19 18.16,2.29
  pour Top (no thermals): 13.08,10.67 16.13,10.67 16.13,8.64 17.14,7.62 18.92,7.62 19.81,6.73 19.81,3.94 18.16,2.29 13.84,2.29 13.84,4.95 15.37,4.95 16.26,5.84 16.26,6.48 15.62,7.11 13.08,7.11
VOUT_CH9
  Top 0.254: R59.2 25.87,3.3 C39.1 29.34,4.45 TP24.TP
  pour Bottom (no thermals): 23.62,2.29 23.62,4.57 26.54,4.57 27.81,5.84 27.81,9.14 28.32,9.65 28.32,11.3 29.84,11.3 30.73,10.41 34.29,10.41 34.54,10.16 34.54,8.51 32,8.51 31.62,8.13 31.62,4.19 29.72,2.29
  pour Top (no thermals): 24.64,10.67 27.69,10.67 27.69,8.64 28.7,7.62 30.48,7.62 31.37,6.73 31.37,3.94 29.72,2.29 25.4,2.29 25.4,4.95 26.92,4.95 27.81,5.84 27.81,6.48 27.18,7.11 24.64,7.11
VOUT_CH10
  Top 0.254: R60.2 37.43,3.3 C40.1 40.89,4.45 TP25.TP
  Bottom 0.406: Q9.3 40.39,13.59 41.02,13.59 41.53,13.08 41.53,10.67 40.42,10.67 R92.1
  pour Bottom (no thermals): 35.18,2.29 35.18,4.57 38.1,4.57 39.37,5.84 39.37,9.14 39.88,9.65 39.88,11.3 41.4,11.3 42.29,10.41 45.85,10.41 46.1,10.16 46.1,8.51 43.56,8.51 43.18,8.13 43.18,4.19 41.27,2.29
  pour Top (no thermals): 36.2,10.67 39.24,10.67 39.24,8.64 40.26,7.62 42.04,7.62 42.93,6.73 42.93,3.94 41.27,2.29 36.96,2.29 36.96,4.95 38.48,4.95 39.37,5.84 39.37,6.48 38.73,7.11 36.2,7.11
VOUT_CH11
  Top 0.254: R61.2 48.98,3.3 C41.1 52.45,4.45 TP26.TP
  pour Bottom (no thermals): 46.74,2.29 46.74,4.57 49.66,4.57 50.93,5.84 50.93,9.14 51.44,9.65 51.44,11.3 52.96,11.3 53.85,10.41 57.4,10.41 57.66,10.16 57.66,8.51 55.12,8.51 54.74,8.13 54.74,4.19 52.83,2.29
  pour Top (no thermals): 47.75,10.67 50.8,10.67 50.8,8.64 51.82,7.62 53.59,7.62 54.48,6.73 54.48,3.94 52.83,2.29 48.51,2.29 48.51,4.95 50.04,4.95 50.93,5.84 50.93,6.48 50.29,7.11 47.75,7.11
VOUT_CH12
  Top 0.254: R62.2 60.54,3.3 C42.1 64.01,4.45 TP27.TP
  pour Bottom (no thermals): 58.29,2.29 58.29,4.57 61.21,4.57 62.48,5.84 62.48,9.14 62.99,9.65 62.99,11.3 64.52,11.3 65.41,10.41 68.96,10.41 69.22,10.16 69.22,8.51 66.67,8.51 66.29,8.13 66.29,4.19 64.39,2.29
  pour Top (no thermals): 59.31,10.67 62.36,10.67 62.36,8.64 63.37,7.62 65.15,7.62 66.04,6.73 66.04,3.94 64.39,2.29 60.07,2.29 60.07,4.95 61.59,4.95 62.48,5.84 62.48,6.48 61.85,7.11 59.31,7.11
VOUT_CH13
  Top 0.254: R63.2 72.1,3.3 C43.1 75.56,4.45 TP28.TP
  pour Top (no thermals): 70.87,10.67 73.91,10.67 73.91,8.64 74.93,7.62 76.71,7.62 77.6,6.73 77.6,3.94 75.95,2.29 71.63,2.29 71.63,4.95 73.15,4.95 74.04,5.84 74.04,6.48 73.41,7.11 70.87,7.11
  pour Bottom (no thermals): 69.85,2.29 69.85,4.57 72.77,4.57 74.04,5.84 74.04,9.14 74.55,9.65 74.55,11.3 76.07,11.3 76.96,10.41 80.52,10.41 80.77,10.16 80.77,8.51 78.23,8.51 77.85,8.13 77.85,4.19 75.95,2.29
VOUT_CH14
  Top 0.254: R64.2 83.65,3.3 C44.1 87.12,4.45 TP29.TP
  pour Bottom (no thermals): 81.41,2.29 81.41,4.57 84.33,4.57 85.6,5.84 85.6,9.14 86.11,9.65 86.11,11.3 87.63,11.3 88.52,10.41 92.08,10.41 92.33,10.16 92.33,8.51 89.79,8.51 89.41,8.13 89.41,4.19 87.5,2.29
  pour Top (no thermals): 82.42,10.67 85.47,10.67 85.47,8.64 86.49,7.62 88.27,7.62 89.15,6.73 89.15,3.94 87.5,2.29 83.19,2.29 83.19,4.95 84.71,4.95 85.6,5.84 85.6,6.48 84.96,7.11 82.42,7.11
VOUT_CH15
  Top 0.254: R65.2 95.21,3.3 C45.1 98.68,4.45 TP30.TP
  pour Bottom (no thermals): 92.96,2.29 92.96,4.57 95.89,4.57 97.16,5.84 97.16,9.14 97.66,9.65 97.66,11.3 99.19,11.3 100.08,10.41 103.63,10.41 103.89,10.16 103.89,8.51 101.35,8.51 100.97,8.13 100.97,4.19 99.06,2.29
  pour Top (no thermals): 93.98,10.67 97.03,10.67 97.03,8.64 98.04,7.62 99.82,7.62 100.71,6.73 100.71,3.94 99.06,2.29 94.74,2.29 94.74,4.95 96.27,4.95 97.16,5.84 97.16,6.48 96.52,7.11 93.98,7.11
VREF
  Bottom 0.406: U23.6 113.52,22.54 R101.2 113.67,22.35 113.67,24 C64.2
VSNSP_CH0  (via drill 0.25)
  Top 0.203: v58.04,24.38 U10.F7 | v19.43,28.83 19.56,28.83 VSNSN48.1
  Route15 0.203: v58.04,24.38 56.9,24.38 56.26,25.02 46.48,25.02 44.96,26.54 44.07,26.54 41.27,29.34 23.11,29.34 21.97,28.19 20.07,28.19 19.81,28.19 19.43,28.57 v19.43,28.83
  Bottom 0.203: 17.91,33.91 R118.2 | 19.56,33.91 C77.2
  Bottom 0.406: VSNSN48.1 19.56,33.91 17.91,33.91
VSNSP_CH1  (via drill 0.25)
  Top 0.203: v64.39,24.38 U10.F12 | v31.11,26.04 VSNSN46.1
  Route2 0.203: v64.39,24.38 63.75,25.02 48.39,25.02 46.99,26.42 33.91,26.42 33.66,26.67 31.75,26.67 v31.11,26.04
  Bottom 0.203: 29.46,33.91 R116.2 | 31.11,33.91 C76.2
  Bottom 0.406: VSNSN46.1 31.11,33.91 29.46,33.91
VSNSP_CH2  (via drill 0.25)
  Top 0.203: v64.39,25.65 U10.E12
  Bottom 0.178: 57.4,27.69 57.4,26.54 57.66,26.29
  Bottom 0.203: 41.02,33.91 R114.2 | 42.67,33.91 C75.2 | v64.39,25.65 63.75,26.29 57.66,26.29 | 57.4,27.69 56.39,28.7 56.39,30.35 51.31,30.35 50.29,31.37 43.05,31.37 42.67,31.75 VSNSN44.1
  Bottom 0.406: VSNSN44.1 42.67,33.91 41.02,33.91
VSNSP_CH3  (via drill 0.25)
  Top 0.203: U10.D12 66.55,26.29 67.18,27.05 v67.18,31.37
  Bottom 0.203: 52.58,33.91 R112.2 | 54.23,33.91 C74.2 | v67.18,31.37 62.36,31.37 62.23,31.5 61.34,31.5 61.21,31.37 54.61,31.37 54.23,31.75 VSNSN42.1
  Bottom 0.406: VSNSN42.1 54.23,33.91 52.58,33.91
VSNSP_CH4
  Top 0.203: U10.C12 66.17,27.56 66.55,27.94 66.55,31.5 VSNSN40.1
  Bottom 0.203: 64.14,33.91 R110.2 | 65.79,33.91 C73.2
  Bottom 0.406: VSNSN40.1 65.79,33.91 64.14,33.91
VSNSP_CH5  (via drill 0.25)
  Top 0.203: U10.B12 v64.39,28.19 | v77.34,28.96 VSNSN38.1
  Route15 0.203: v77.34,28.96 75.44,28.96 74.93,28.45 64.64,28.45 v64.39,28.19
  Bottom 0.203: 75.69,33.91 R108.2 | 77.34,33.91 C72.2
  Bottom 0.406: VSNSN38.1 77.34,33.91 75.69,33.91
VSNSP_CH6  (via drill 0.25)
  Top 0.203: U10.A12 v65.66,30.73 | v88.9,30.73 VSNSN36.1
  Bottom 0.203: 87.25,33.91 R106.2 | 88.9,33.91 C71.2 | v65.66,30.73 v88.9,30.73
  Bottom 0.406: VSNSN36.1 88.9,33.91 87.25,33.91
VSNSP_CH7  (via drill 0.25)
  Top 0.203: U10.A7 v59.31,29.46 | v100.46,30.23 VSNSN34.1
  Route15 0.203: v59.31,29.46 59.94,28.83 74.55,28.83 75.31,29.59 85.34,29.59 85.6,29.34 90.68,29.34 91.57,30.23 v100.46,30.23
  Bottom 0.203: 98.81,33.91 R104.2 | 100.46,33.91 C70.2
  Bottom 0.406: VSNSN34.1 100.46,33.91 98.81,33.91
VSNSP_CH8  (via drill 0.25)
  Top 0.203: v58.04,15.49 U10.M7
  Bottom 0.203: 17.27,12.45 R96.2 | C62.2 15.62,12.45 | v58.04,15.49 58.04,15.37 50.29,15.37 49.78,14.86 16.38,14.86 VSNSN31.1
  Bottom 0.406: VSNSN31.1 15.62,12.45 17.27,12.45
VSNSP_CH9  (via drill 0.25)
  Top 0.203: v64.39,15.49 U10.M12 | VSNSN29.1 v27.18,15.49
  Route15 0.203: v27.18,15.49 27.3,15.62 53.59,15.62 54.1,16.13 58.93,16.13 59.44,16.64 63.25,16.64 v64.39,15.49
  Bottom 0.203: 28.83,12.45 R94.2 | C61.2 27.18,12.45
  Bottom 0.406: VSNSN29.1 27.18,12.45 28.83,12.45
VSNSP_CH10  (via drill 0.25)
  Top 0.203: v64.39,16.76 U10.L12 | VSNSN27.1 v38.73,16.64
  Route15 0.203: v38.73,16.64 38.99,16.89 42.67,16.89 43.43,16.13 53.34,16.13 53.72,16.51 58.67,16.51 59.18,17.02 63.63,17.02 63.88,16.76 v64.39,16.76
  Bottom 0.203: 40.39,12.45 R92.2 | C60.2 38.73,12.45
  Bottom 0.406: VSNSN27.1 38.73,12.45 40.39,12.45
VSNSP_CH11  (via drill 0.25)
  Top 0.203: v65.66,15.49 65.73,15.6 65.73,16.33 66.17,16.76 66.55,16.76 66.55,18.29 66.17,18.67 U10.K12
  Bottom 0.203: 51.94,12.45 R90.2 | C59.2 50.29,12.45 | v65.66,15.49 65.02,16.13 61.21,16.13 59.94,14.86 51.05,14.86 VSNSN25.1
  Bottom 0.406: VSNSN25.1 50.29,12.45 51.94,12.45
VSNSP_CH12  (via drill 0.25)
  Top 0.203: v66.55,16.13 66.8,16.13 66.93,16.26 66.93,19.56 66.55,19.94 U10.J12
  Route15 0.203: VSNSN23.1 61.85,14.61 62.1,14.86 66.04,14.86 66.55,15.37 v66.55,16.13
  Bottom 0.203: 63.5,12.45 R88.2 | C58.2 61.85,12.45
  Bottom 0.406: VSNSN23.1 61.85,12.45 63.5,12.45
VSNSP_CH13
  Top 0.203: U10.H12 66.8,21.21 69.6,18.41 71.5,18.41 73.41,16.51 VSNSN21.1
  Bottom 0.203: 75.06,12.45 R86.2 | C57.2 73.41,12.45
  Bottom 0.406: VSNSN21.1 73.41,12.45 75.06,12.45
VSNSP_CH14  (via drill 0.25)
  Top 0.203: U10.G12 v65.66,23.11 | v84.96,17.53 VSNSN19.1
  Route15 0.203: v65.66,23.11 65.66,22.35 66.04,21.97 69.09,21.97 72.64,18.41 77.98,18.41 78.23,18.16 84.33,18.16 v84.96,17.53
  Bottom 0.203: 86.61,12.45 R84.2 | 84.96,12.45 C56.2
  Bottom 0.406: VSNSN19.1 84.96,12.45 86.61,12.45
VSNSP_CH15  (via drill 0.25)
  Top 0.203: U10.G7 v59.31,21.84 | v96.52,16.26 VSNSN17.1
  Route15 0.203: v59.31,21.84 60.96,21.84 63.25,19.56 68.33,19.56 69.09,18.8 69.09,16.64 69.34,16.38 75.06,16.38 75.56,16.89 76.83,16.89 77.6,16.13 92.2,16.13 92.58,16.51 92.96,16.89 95.12,16.89 95.89,16.13 96.52,16.13 v96.52,16.26
  Bottom 0.203: 98.17,12.45 R82.2 | 96.52,12.45 C55.2
  Bottom 0.406: VSNSN17.1 96.52,12.45 98.17,12.45

## Text on the board
tPlace: CH0 1.0V | CH1 1.1V | CH2 1.2V | CH3 1.3V | CH4 1.4V | CH5 1.5V | CH6 1.7V | CH7 1.8V | GND | INSTALL CONNECTORS | ON TOP SIDE | F | E | M | A | L | E | GND | 6-14V | 0.3A | 0.3A | 0.3A | 0.3A | 0.3A | 0.3A | 0.3A | 0.3A | SCL | - | + | SHARE_CLK | CONTROL | SDA | LTM2987CY | FAULT | ALERT | DEMO CIRCUIT 2023A | LTM2987CY | + | 16-CHANNEL | ALERT | GND | GND | GND | GND | POWER SYSTEM | MANAGER | +5V | FAULT | RESET | CREATE FAULT | RUN | OFF | CONTROL | 0.3A | 0.3A | 0.3A | 0.3A | 0.3A | 0.3A | 0.3A | 0.3A | M | A | L | E | RESET | CH8 2.0V | CH9 2.2V | CH10 2.5V | CH11 2.7V | CH12 3.0V | CH13 3.1V | CH14 3.2V | CH15 3.3V
bPlace: CH0 1.0V | CH1 1.1V | CH2 1.2V | CH3 1.3V | CH4 1.4V | CH5 1.5V | CH6 1.7V | CH7 1.8V | REV 1 | RUN | VS | DAC | RUN | VS | DAC | RUN | VS | DAC | RUN | VS | DAC | DAC | RUN | VS | DAC | RUN | VS | DAC | RUN | VS | DAC | RUN | VS | LTC CONFIDENTIAL - FOR CUSTOMER USE ONLY | DAC | VS | RUN | DAC | VS | RUN | DAC | VS | RUN | DAC | VS | RUN | DAC | VS | RUN | DAC | VS | RUN | DAC | VS | RUN | DAC | VS | RUN | OPEN | A2 | A1 | MUX | SCLK | A0 | 1 | CH8 2.0V | CH9 2.2V | CH10 2.5V | CH11 2.7V | CH12 3.0V | CH13 3.1V | CH14 3.2V | CH15 3.3V
tStop: KVL | LTM2987CY | 16-CHANNEL | POWER MANAGER | (408) 432-1900 | www.linear.com
bStop: POWER MANAGER | 16-CHANNEL | LTM2987CY | (408) 432-1900 | www.linear.com
d_FabDrawing: DRILL TABLE | 1.825" | 0.00" | 5.185" | 0.00" | SHOWN FROM TOP SIDE